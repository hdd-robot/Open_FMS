* /home/ros/workspace_cpp/hermas_box/gps/kicad/hermas_box/hermas_box.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: mar. 24 avril 2018 16:06:16 CEST

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
S1  GND GND GND Net-_C13-Pad1_ Net-_C13-Pad1_ Net-_C13-Pad1_ VDD_EXT Net-_Q3-Pad1_ ? ? ? ? ? TX_sim RX_sim RESET_SIM Net-_C16-Pad1_ GND ? ? ? ? ? ? ? ? ? GND Net-_C18-Pad1_ Net-_ESD1-Pad5_ Net-_ESD1-Pad1_ Net-_ESD1-Pad3_ ? GND Net-_AE2-Pad1_ GND ? ? ? GND ? ? ? ? ? ? ? ? CHECK_PWR_SIM ? GND GND ? GND ? ? ? ? ? ? ? ? ? GND GND Net-_AE1-Pad1_ GND GND Sim808
Y1  GND GND 16Mhz
AE2  Net-_AE2-Pad1_ GND Antenna_GPS
AE1  Net-_AE1-Pad1_ GND Antenna_GSM
S2  Net-_C18-Pad1_ Net-_ESD1-Pad3_ Net-_ESD1-Pad1_ ? GND ? Net-_ESD1-Pad5_ ? SIM_CONN
C1  Net-_C1-Pad1_ GND 22pF
U2  Net-_U1-Pad2_ GND 5V Net-_U1-Pad1_ ? Net-_P5-Pad2_ Net-_P5-Pad1_ CAN_SILMODE TJA1051T
R16  Net-_P5-Pad1_ Net-_P5-Pad2_ 120R
MIC1  5V 5V GND Net-_C13-Pad1_ Net-_MIC1-Pad5_ MIC29302
C9  5V GND 100uF
C10  5V GND 1uF
R11  GND Net-_MIC1-Pad5_ 43K
R12  Net-_C13-Pad1_ Net-_MIC1-Pad5_ 100K
C13  Net-_C13-Pad1_ GND 330uF
C14  Net-_C13-Pad1_ GND 100nF
R13  Net-_C13-Pad1_ GND 470R
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ GND BC237
R15  GND Net-_Q3-Pad2_ 47K
R14  Net-_Q3-Pad2_ PWR_SIM 4.7K
C18  Net-_C18-Pad1_ GND 100nF
Y2  GND GND 8Mhz
C12  Net-_C12-Pad1_ GND 22pF
C11  Net-_C11-Pad1_ GND 22pF
P5  Net-_P5-Pad1_ Net-_P5-Pad2_ CONN_01X02
P4  5V GND CONN_01X02
C2  Net-_C2-Pad1_ GND 22pF
P2  Net-_IC1-Pad2_ Net-_IC1-Pad3_ GND CONN_01X03
C5  5V GND 100nf
C4  5V GND 100nf
C6  5V GND 100nf
C8  5V GND 100nf
IC1  ? Net-_IC1-Pad2_ Net-_IC1-Pad3_ ? ? ? ? ? ? 5V GND ? ? ? ? ? ? ? Net-_IC1-Pad19_ Net-_IC1-Pad20_ Net-_IC1-Pad21_ Net-_IC1-Pad22_ ? ? ? ? ? ? ? RESET 5V GND Net-_C1-Pad1_ Net-_C2-Pad1_ ? ? ? ? ? ? ? ? CAN_INT CHECK_PWR_SIM RX1 TX1 ? ? ? ? ? ? Net-_D1-Pad2_ Net-_D2-Pad2_ Net-_D3-Pad2_ ? ? ? ? ? 5V GND ? ? ? ? ? ? ? ? ? ? ? CAN_RESET ? CAN_SILMODE ? PWR_SIM ? 5V GND ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? Net-_C3-Pad1_ GND 5V ATMEGA1280-A_HD
C7  5V GND 100nf
R1  RESET 5V 10K
P1  GND RESET CONN_01X02
P3  RESET RESET_SIM Net-_IC1-Pad19_ CAN_CS Net-_IC1-Pad20_ CAN_SCK Net-_IC1-Pad21_ CAN_SO Net-_IC1-Pad22_ CAN_SI GND GND 5V 5V CONN_02X07
ESD1  Net-_ESD1-Pad1_ GND Net-_ESD1-Pad3_ Net-_C18-Pad1_ Net-_ESD1-Pad5_ ESDA6V1SC5
R4  5V RX1 4.7K
R3  VDD_EXT Net-_Q1-Pad1_ 4.7K
R2  Net-_Q1-Pad1_ TX_sim 47K
R7  TX1 5V 47K
R5  RX_sim VDD_EXT 4.7K
R6  Net-_Q2-Pad1_ VDD_EXT 4.7K
Q1  Net-_Q1-Pad1_ TX_sim RX1 2SC4617TLR
Q2  Net-_Q2-Pad1_ TX1 RX_sim 2SC4617TLR
C17  5V GND 100nf
C15  5V GND 100nf
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ ? ? ? ? ? Net-_C11-Pad1_ Net-_C12-Pad1_ GND ? ? CAN_INT CAN_SCK ? CAN_SI CAN_SO CAN_CS CAN_RESET 5V MCP2515-E/ST
C3  Net-_C3-Pad1_ GND 100nf
C16  Net-_C16-Pad1_ GND 4.7uf
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ LED
R8  Net-_D1-Pad1_ GND 180
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ LED
R9  Net-_D2-Pad1_ GND 180
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ LED
R10  Net-_D3-Pad1_ GND 180
D4  Net-_D4-Pad1_ CHECK_PWR_SIM LED
R17  Net-_D4-Pad1_ GND 180

.end
